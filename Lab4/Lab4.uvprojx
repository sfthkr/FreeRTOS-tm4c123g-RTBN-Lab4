# Keil uVision project Lab4.uvprojx, settings and files
target Target (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab4
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --C99
  c include: ../inc;..;..\..\..;FreeRtos\Source\include;FreeRtos\Source\portable\RVDS\ARM_CM4F;.\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source code
    ./: Lab4.c PLL.c texas.o
    ../inc/: BSP.c Profile.c CortexM.c
    ./FreeRtos/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRtos/Source/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRtos/Source/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.1
